# Keil uVision project STM32F407_APP.uvprojx, settings and files
target STM32F407_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407_APP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,CMB_USER_CFG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../00_Config;../00_Config/diagnostics;../01_APP;../02_Service;../02_Service/log;../03_Platform/platform_common;../03_Platform/platform_os;../03_Platform/platform_log;../04_Impl/diagnostics;../04_Impl/diagnostics/easylogger;../04_Impl/impl_board;../04_Impl/impl_os/freertos;../05_Vendors/CmBacktrace;../05_Vendors/CmBacktrace/Languages/en-US;../05_Vendors/EasyLogger/inc;../05_Vendors/SEGGER_RTT
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fsmc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/Platform/platform_common
    ../03_Platform/platform_common/: platform_def.h platform_device.c platform_device.h platform_error.h platform_lifecycle.h platform_object.c platform_object.h platform_service.c platform_service.h platform_types.h
  group Application/Platform/platform_os
    ../03_Platform/platform_os/: platform_event_flags.h platform_mutex.h platform_notify.h platform_os.h platform_os_types.h platform_queue.h platform_semaphore.h platform_thread.h platform_time.h platform_timer.h
  group Application/Impl/impl_board
    ../04_Impl/impl_board/: board_types.h
  group Application/Impl/impl_os/freertos
    ../04_Impl/impl_os/freertos/: impl_freertos_common.h impl_freertos_event_flags.c impl_freertos_mutex.c impl_freertos_notify.c impl_freertos_queue.c impl_freertos_semaphore.c impl_freertos_thread.c impl_freertos_time.c impl_freertos_timer.c
  group Application/Vendors/SEGGER_RTT
    ../05_Vendors/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group Application/Vendors/CmBacktrace
    ../05_Vendors/CmBacktrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../05_Vendors/CmBacktrace/Languages/en-US/: cmb_en_US.h
  group Application/Config/Diagnostics
    ../00_Config/diagnostics/: cmb_user_cfg.h diagnostics_config.h freertos_tasks_c_additions.h service_log_config.h
  group Application/Impl/Diagnostics
    ../04_Impl/diagnostics/: cmbacktrace_port.c cmbacktrace_port.h diagnostics_fault.c diagnostics_fault.h cmbacktrace_fault_handlers.S diagnostics_fault_trigger.S
  group Application/Service/log
    ../02_Service/log/: service_log.c service_log.h
  group Application/Platform/platform_log
    ../03_Platform/platform_log/: platform_log.h
  group Application/Impl/diagnostics/easylogger
    ../04_Impl/diagnostics/easylogger/: easylogger_port.c easylogger_port.h elog_port.c
  group Application/Vendors/EasyLogger
    ../05_Vendors/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../05_Vendors/EasyLogger/inc/: elog.h elog_cfg.h
software components: CMSIS:CORE 4.3.0
